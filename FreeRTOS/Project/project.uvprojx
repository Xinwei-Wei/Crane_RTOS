# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\User;..\Hardware\ADC;..\Hardware\Beep;..\Hardware\CCD;..\Hardware\Encoder;..\Hardware\EXTI;..\Hardware\Filter_Mathod;..\Hardware\FreeCars;..\Hardware\HC05;..\Hardware\HC-SR04;..\Hardware\Key;..\Hardware\LED;..\Hardware\Mecanum;..\Hardware\Menu;..\Hardware\OLED;..\Hardware\PID;..\Hardware\PWM;..\Hardware\Servo;..\Hardware\SoftIIC;..\Hardware\StepperMotor;..\Hardware\Sys;..\Hardware\TF-Luna;..\Hardware\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
  group Hardware
    ../Hardware/ADC/: adc.c
    ../Hardware/Beep/: beep.c
    ../Hardware/CCD/: ccd.c
    ../Hardware/Encoder/: encoder.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/Filter_Mathod/: filter_mathod.c
    ../Hardware/FreeCars/: freecars.c
    ../Hardware/HC05/: hc05.c
    ../Hardware/HC-SR04/: hc-sr04.c
    ../Hardware/Key/: key.c
    ../Hardware/LED/: led.c
    ../Hardware/Mecanum/: mecanum_control.c
    ../Hardware/Menu/: menu.c
    ../Hardware/OLED/: oled.c
    ../Hardware/PID/: pid.c
    ../Hardware/PWM/: pwm.c
    ../Hardware/Servo/: servo.c
    ../Hardware/SoftIIC/: softiic.c
    ../Hardware/StepperMotor/: stepper_motor.c
    ../Hardware/Sys/: sys.c
    ../Hardware/TF-Luna/: tf-luna.c
    ../Hardware/USART/: usart.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ../User/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
software components: CMSIS:CORE 5.4.0
