# Keil uVision project CraneRTOS.uvprojx, settings and files
target Crane_RTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Crane_RTOS +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\softiic;..\USER;..\FWLIB\inc;..\HARDWARE\OLED;..\HARDWARE\FREECARS;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\PWM;..\HARDWARE\LED;..\HARDWARE\HC05;..\HARDWARE\EXTI;..\HARDWARE\BEEP;..\HARDWARE\MENU;..\HARDWARE\HC-SR04;..\HARDWARE\CCD;..\HARDWARE\Filter_Mathod;..\HARDWARE\ADC;..\HARDWARE\TF-Luna;..\uCOS-III\uC-CPU;..\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\uCOS-III\uC-LIB;..\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\uCOS-III\APP;..\uCOS-III\BSP;..\uCOS-III\uCOS-III\Source;..\HARDWARE\PID;..\HARDWARE\Mecanum;..\HARDWARE\ENCODER;..\HARDWARE\StepperMotor;..\HARDWARE\SERVO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/softiic/: softiic.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/FREECARS/: freecars.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MENU/: menu.c
    ../HARDWARE/HC-SR04/: hc-sr04.c
    ../HARDWARE/CCD/: ccd.c
    ../HARDWARE/Filter_Mathod/: filter_mathod.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/TF-Luna/: tf-luna.c
    ../HARDWARE/Mecanum/: mecanum_control.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/StepperMotor/: stepper_motor.c
    ../HARDWARE/SERVO/: servo.c
  group uC/OS-III CPU
    ../uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/OS-III LIB
    ../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Port
    ../uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC/OS-III Source
    ../uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III APP
    ../uCOS-III/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32f4xx.h stm32f4xx_conf.h
  group uC/OS-III BSP
    ../uCOS-III/BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cstartup.s
